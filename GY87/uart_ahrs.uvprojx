# Keil uVision project uart_ahrs.uvprojx, settings and files
target IMU_AHRS (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uart_ahrs +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: .\StartUp;.\User_Src;.\Lib\inc;.\HardWareDriver;.\HardWareDriver\BMP085;.\HardWareDriver\HMC5883L;.\HardWareDriver\IMU;.\HardWareDriver\LED;.\HardWareDriver\MPU6050;.\HardWareDriver\UART2;.\HardWareDriver\UARTs;.\HardWareDriver\EEPROM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group StartUp
    ./StartUp/: core_cm3.c system_stm32f10x.c startup_stm32f10x_md.s
  group HardWareDriver
    ./HardWareDriver/: delay.c IOI2C.c
    ./HardWareDriver/HMC5883L/: HMC5883L.c
    ./HardWareDriver/IMU/: IMU.c
    ./HardWareDriver/LED/: LED.c
    ./HardWareDriver/MPU6050/: MPU6050.c
    ./HardWareDriver/UARTs/: UARTs.c
    ./HardWareDriver/EEPROM/: eeprom.c
  group User_Src
    ./User_Src/: main.c stm32f10x_it.c
  group Lib
    ./Lib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_flash.c
software components: CMSIS:CORE 4.3.0
